# Keil uVision project bootloader.uvprojx, settings and files
target dfu_single_bank_hci (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.1.1.3
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: bootloader +hex
  c flags: Optim=1 wLevel=2
  c define: NRF51,DEBUG_NRF_USER,BOARD_NRF6310, BOOTLOADER_BANKED BLE_STACK_SUPPORT_REQD
  c misc: --c99
  c include: ..;..\include;..\..\..\..\..\Include\bootloader_dfu;..\..\..\..\..\Include\bootloader_dfu\hci_transport;..\..\..\..\..\Include;..\..\..\..\..\Include\sd_common;..\..\..\..\..\Include\app_common;..\..\..\..\..\Include\ble;..\..\..\..\..\Include\ble\ble_services;..\..\..\..\..\Include\s110
  memory RVCT4: ROM 0x3a000 size 0x6000
  memory RVCT9: RAM 0x20002000 size 0x2000
  group Startup Code
    ./../../../../../Source/templates/: system_nrf51.c
    ../: arm_startup_nrf51.s
  group Source Code
    ./../: main.c
    ../../../../../Source/bootloader_dfu/: dfu_single_bank.c bootloader_util_arm.c bootloader_settings_arm.c
    ../: dfu_dual_bank.c bootloader.c
  group Services
    ../: ble_dfu.c
  group Libraries
    ../../../../../Source/app_common/: hci_mem_pool.c app_timer.c app_scheduler.c app_gpiote.c crc16.c pstorage.c app_button.c
    ../../../../../Source/sd_common/: softdevice_handler.c
    ../../../../../Source/nrf_delay/: nrf_delay.c
    ../../../../../Source/ble/: ble_debug_assert_handler.c
  group BLE Transport
    ../../../../../Source/ble/: ble_conn_params.c ble_advdata.c
    ../../../../../Source/ble/ble_services/: ble_srv_common.c
    ../: dfu_transport_ble.c
  group HCI Transport
    ../../../../../Source/bootloader_dfu/: dfu_transport_serial.c
    ../../../../../Source/app_common/: hci_transport.c hci_slip.c app_uart.c
target dfu_dual_bank_hci (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.1.1.3
  cpu: as above
  output: bootloader +hex
  c flags: Optim=4 wLevel=2
  c define: as above
  c misc: --c99
  c include: as above
  memory RVCT4: ROM 0x3c000 size 0x4000
  memory RVCT9: RAM 0x20002000 size 0x2000
target dfu_dual_bank_ble (s110) (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.1.1.3
  cpu: as above
  output: bootloader +hex
  c flags: Optim=1 wLevel=2
  c define: as above
  c misc: --c99
  c include: ..;..\include;..\..\..\..\..\Include\bootloader_dfu_Debug;..\..\..\..\..\Include\bootloader_dfu_Debug\ble_transport;..\..\..\..\..\Include;..\..\..\..\..\Include\sd_common;..\..\..\..\..\Include\app_common;..\..\..\..\..\Include\ble;..\..\..\..\..\Include\ble\ble_services;..\include\S130_mbr
  memory RVCT4: ROM 0x3a000 size 0x6000
  memory RVCT9: RAM 0x20002800 size 0x1800
